#pragma once
#include "ns2_input.h"

namespace ns2 {
struct FeedbackStamp {
    uint32_t source_epoch=0;
    uint64_t received_us=0;
};
inline bool feedback_matches_source(const FeedbackStamp &stamp,const InputSnapshot &input,uint64_t now_us) {
    return input.valid && stamp.source_epoch==input.source_epoch && now_us>=stamp.received_us &&
           now_us-stamp.received_us<=static_cast<uint64_t>(kInputStaleMs)*1000;
}

// Only the exact all-zero-amplitude packet generated by build_pro2_hd_packet
// may bypass input freshness. Header counters must match for both motors.
inline bool feedback_is_neutral_stop(const uint8_t *data,size_t length) {
    if(!data || length!=33 || data[0]!=0 || (data[1]&0xf0)!=0x50 || data[17]!=data[1])return false;
    constexpr uint8_t neutral[5]={0xe1,0x00,0x10,0x1e,0x00};
    for(unsigned motor=0;motor<2;motor++) {
        for(unsigned frame=0;frame<3;frame++) {
            const size_t offset=2+motor*16+frame*5;
            for(unsigned byte=0;byte<5;byte++)if(data[offset+byte]!=neutral[byte])return false;
        }
    }
    return true;
}

inline bool feedback_ble_allowed(const uint8_t *data,size_t length,uint32_t source_epoch,const InputSnapshot &input) {
    return source_epoch==input.source_epoch && (input.valid || feedback_is_neutral_stop(data,length));
}
}
